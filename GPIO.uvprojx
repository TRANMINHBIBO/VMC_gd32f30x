# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c gd32f30x_it.c systick.c atc_e25.c atc_e25.h task_atc25.h task_atc25.c
software components: CMSIS:CORE 6.1.0, RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Coroutines 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Message Buffer 11.1.0, RTOS:Stream Buffer 11.1.0, RTOS:Timers 11.1.0, Device:GD32F30x_StdPeripherals:ADC 1.0.2, Device:GD32F30x_StdPeripherals:EXTI 1.0.2, Device:GD32F30x_StdPeripherals:GPIO 1.0.2, Device:GD32F30x_StdPeripherals:I2C 1.0.2, Device:GD32F30x_StdPeripherals:MISC 1.0.2, Device:GD32F30x_StdPeripherals:PMU 1.0.2, Device:GD32F30x_StdPeripherals:RCU 1.0.2, Device:GD32F30x_StdPeripherals:TIMER 1.0.2, Device:GD32F30x_StdPeripherals:USART 1.0.2, Device:GD32F30x_libopt 1.0.2, Device:Startup 1.0.2
